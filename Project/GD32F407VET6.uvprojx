# Keil uVision project GD32F407VET6.uvprojx, settings and files
target GD32F407 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407VET6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407,SYS_SUPPORT_OS
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Hardware\bsp_usart0;..\Hardware\bsp_timer8;..\Driver\steering_drv;..\Driver\VL53L0X;..\Driver\VL53L0X\core\inc;..\Driver\VL53L0X\platform\inc;..\Hardware\bsp_iic0;..\Driver\bsp_keys;..\App;..\Driver\OLED;..\Middleware\circular_queue;..\Middleware\freeRTOS;..\Middleware\freeRTOS\include;..\Middleware\freeRTOS\portable\GCC\ARM_CM4F;..\Hardware\bsp_iic_soft
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group App
    ../App/: App_Input.c App_Protocol.c App_Show.c
  group Middleware
    ../Middleware/circular_queue/: circular_queue.c
  group Driver
    ../Driver/steering_drv/: steering_drv.c
    ../Driver/bsp_keys/: bsp_keys_driver.c
    ../Driver/OLED/: oled.c
    ../Driver/DHT11/: DHT11.c
    ../Driver/BH1750/: BH1750.c
  group Hardware
    ../Hardware/bsp_usart0/: bsp_usart0.c
    ../Hardware/bsp_timer8/: bsp_timer8.c
    ../Hardware/bsp_iic0/: bsp_iic0.c
    ../Hardware/bsp_iic_soft/: bsp_iic_soft.c bsp_iic_soft.h
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_dma.c gd32f4xx_timer.c gd32f4xx_i2c.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group freeRTOS/Core
    ../Middleware/freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS/Port
    ../Middleware/freeRTOS/portable/MemMang/: heap_4.c
    ../Middleware/freeRTOS/portable/GCC/ARM_CM4F/: port.c
